# IAR project mb9bf51xn_template.ewp, settings and files
configuration MB9BF512N_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF512N Fujitsu MB9BF512N
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\example\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf51xn_template.srec
  ILINK.IlinkOutputFile: mb9bf51xn_template.out
  ILINK.IlinkIcfFile: config\mb9bf512_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB9BF514N_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF514N Fujitsu MB9BF514N
  ILINK.IlinkIcfFile: config\mb9bf514_ram.icf
configuration MB9BF515N_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF515N Fujitsu MB9BF515N
  ILINK.IlinkIcfFile: config\mb9bf515_ram.icf
configuration MB9BF516N_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF516N Fujitsu MB9BF516N
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: config\mb9bf516_ram.icf
configuration MB9BF512N_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration MB9BF514N_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF514N Fujitsu MB9BF514N
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration MB9BF515N_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF515N Fujitsu MB9BF515N
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration MB9BF516N_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF516N Fujitsu MB9BF516N
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: Readme.txt
  group common
    ../../common/: system_mb9bf51x.c
  group source_files
    ../source/: ADC.c ClarkePark.c Ext_INT.c Interrupt.c main.c Motor.c pid.c PWM.c QPRC.c svm.c
    ./: startup_mb9bf51x.s
