# Keil uVision project mb9bf51xn_template.uvproj, settings and files
target MB9BF512N_Debug (ARM-ADS)
  device: MB9BF512N Fujitsu Semiconductors
  cpu: IRAM(0x20000000-0x20001FFF) IRAM2(0x1FFFE000-0x1FFFFFFF) IROM(0x00000000-0x0001FFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: mb9bf51xn_template
  c flags: Optim=1
  c include: ..\..\common;..\..\example\source
  memory RVCT4: ROM 0x1fffe000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group common
    ../../common/: system_mb9bf51x.c
  group source_files
    ../source/: main.c
    ../../: Readme.txt
    ./: startup_mb9bf51x.s FLASH_DEBUG_README.txt
target MB9BF514N_Debug (ARM-ADS)
  device: MB9BF514N Fujitsu Semiconductors
  cpu: IRAM(0x20000000-0x20003FFF) IRAM2(0x1FFFC000-0x1FFFFFFF) IROM(0x00000000-0x0003FFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: mb9bf51xn_template
  c flags: Optim=1
  c include: ..\..\common;..\..\example\source
  memory RVCT4: ROM 0x1fffc000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
target MB9BF515N_Debug (ARM-ADS)
  device: MB9BF515N Fujitsu Semiconductors
  cpu: IRAM(0x20000000-0x20005FFF) IRAM2(0x1FFFA000-0x1FFFFFFF) IROM(0x00000000-0x0005FFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: mb9bf51xn_template
  c flags: Optim=1
  c include: ..\..\common;..\..\example\source
  memory RVCT4: ROM 0x1fffa000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x6000
target MB9BF516N_Debug (ARM-ADS)
  device: MB9BF516N Fujitsu Semiconductors
  cpu: IRAM(0x20000000-0x20007FFF) IRAM2(0x1FFF8000-0x1FFFFFFF) IROM(0x00000000-0x0007FFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: mb9bf51xn_template
  c flags: Optim=1
  c include: ..\..\common;..\..\example\source
  memory RVCT4: ROM 0x1fff8000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
target MB9BF512N_Release (ARM-ADS)
  device: MB9BF512N Fujitsu Semiconductors
  cpu: as above
  output: mb9bf51xn_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\example\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
target MB9BF514N_Release (ARM-ADS)
  device: MB9BF514N Fujitsu Semiconductors
  cpu: as above
  output: mb9bf51xn_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\example\source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
target MB9BF515N_Release (ARM-ADS)
  device: MB9BF515N Fujitsu Semiconductors
  cpu: as above
  output: mb9bf51xn_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\example\source
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffa000 size 0x6000
target MB9BF516N_Release (ARM-ADS)
  device: MB9BF516N Fujitsu Semiconductors
  cpu: as above
  output: mb9bf51xn_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\example\source
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
